# Keil uVision project sixuanyi.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: sixuanyi +hex
  c flags: Optim=1
  c define: STM32F10X_HD,DEBUG,USE_STDPERIPH_DRIVER
  c include: ..\libraries\CM3;..\libraries\CM3\inc;..\project;..\drivers;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../app/: main.c
    ../drivers/: stm32f10x_it.c
  group cm3
    ../libraries/CM3/: startup_stm32f10x_hd.s system_stm32f10x.c core_cm3.c stm32f10x_conf.h
  group libraries
    ../libraries/CM3/src/: stm32f10x_gpio.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group drivers
    ../drivers/: bsp.c sensors.c iic.c mpu6050.c hmc5883l.c bmp085.c rc.c pwm.c eeprom.c uart.c
  group app
    ../app/: enviroment.c ahrs.c Mymath.c parameter.c controller.c ekf.c
